# Keil uVision project calcul_dephasage.uvprojx, settings and files
target projet (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: calcul_dephasage
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx
  c include: .\librarie\STM32F4xx_StdPeriph_Driver\inc;.\librarie\CMSIS
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group system
    ../../Desktop/2GE_complet/2GE/logiciels/keil_V5/librairie/: startup_stm32f411xe_FPU.s
    ../../Desktop/2GE_complet/2GE/microcontroleurs_2GE2_exemples_faits _en_classe_2022/microcontroleurs_2GE_exemples_faits _en_classe/frequence_variable/variation_frequence_par_CH10/librairie/: startup_stm32f411xe.s
    ../../Desktop/2GE_complet/2GE/microcontroleurs_2GE2_exemples_faits _en_classe_2022/microcontroleurs_2GE_exemples_faits _en_classe/frequence_variable/variation_frequence_par_CH10/librairie/STM32F4xx_StdPeriph_Driver/src/: system_stm32f4xx.c
  group user
    ./: main.c configure_clock.c configure_gpio.c configure_dac.c configure_adc.c configure_timer3.c configure_NVIC.c timer3_interrupt_handler.c read_potentiometer.c detect_zero_crossings.c
  group librairies
    ../../Desktop/2GE_complet/2GE/logiciels/keil_V5/librairie/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_dac.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_adc.c
software components: CMSIS:CORE 5.0.1, Device:Startup 2.6.0
